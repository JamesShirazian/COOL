# Keil uVision project SD_File.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SD_File
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
  group Configuration Files
    ./: LPC2300.s File_Config.c MCI_LPC23xx.c RTX_Config.c
  group Com Port
    ./: Retarget.c Serial.c
  group RT Agent
    ./: RTA_Config.c
  group Documentation
    ./: Abstract.txt
  group Main
    ./: main.cpp
  group LCD
    ./: LCD.h LCD.cpp
  group ADC
    ./: ADC.cpp ADC.h
  group DAC
    ./: DAC.cpp DAC.h
  group Port
    ./: PortPin.cpp PortPin.h
  group SerialPort
    ./: SerialPort.h SerialPort.cpp
  group RTC
    ./: type.h RealTimeClock.cpp RealTimeClock.h
  group Interrupt
    ./: Interrupt.cpp Interrupt.h
  group AttachedTimer
    ./: AttachedTimer.cpp AttachedTimer.h
  group StopWatch
    ./: StopWatch.cpp StopWatch.h
  group Timer
    ./: Timer.cpp Timer.h
  group Buzzer
    ./: Buzzer.cpp Buzzer.h
  group Key
    ./: Key.cpp Key.h
  group SDCard
    ./: SDCard.cpp SDCard.h
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
target MCB2300 RT_Agent (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: SD_File
  c flags: Optim=4
  c define: RT_AGENT
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
